options:
  parameters:
    category: GPS Lab
    description: C/N0 from prompt and noise correlators, stock blocks only
    generate_options: hb
    id: gps_cn0_meter
    output_language: python
    title: GPS C/N0 meter
  states: {}

blocks:
- name: alpha
  id: parameter
  parameters:
    comment: 0.02 at 1 kHz = ~50 ms
    label: Smoothing alpha
    type: eng_float
    value: '0.02'
  states: {}
- name: in0_p
  id: pad_source
  parameters:
    comment: prompt correlator, 1 kHz
    label: P
    type: complex
  states: {}
- name: in1_n
  id: pad_source
  parameters:
    comment: other-PRN correlator = noise only
    label: N
    type: complex
  states: {}
- name: pm2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: nm2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: pavg
  id: single_pole_iir_filter_xx
  parameters:
    type: float
    alpha: alpha
  states: {}
- name: navg
  id: single_pole_iir_filter_xx
  parameters:
    type: float
    alpha: alpha
  states: {}
- name: ratio
  id: blocks_divide_xx
  parameters:
    comment: '|P|^2 / |N|^2 = 1 + SNR(1 ms)'
    type: float
  states: {}
- name: minus1
  id: blocks_add_const_vxx
  parameters:
    comment: SNR(1 ms)
    type: float
    const: '-1.0'
  states: {}
- name: floor
  id: analog_const_source_x
  parameters:
    comment: 'floor: SNR >= 1e-3 (0 dB-Hz)'
    type: float
    const: '1e-3'
  states: {}
- name: clip
  id: blocks_max_xx
  parameters:
    comment: max(SNR, floor)
    type: float
    num_inputs: '2'
  states: {}
- name: db
  id: blocks_nlog10_ff
  parameters:
    comment: 10log10(SNR) + 30 = 10log10(SNR / 1 ms) = C/N0 [dB-Hz]
    n: '10'
    k: '30'
  states: {}
- name: out0_cn0
  id: pad_sink
  parameters:
    label: cn0
    type: float
  states: {}

connections:
- [in0_p, '0', pm2, '0']
- [in1_n, '0', nm2, '0']
- [pm2, '0', pavg, '0']
- [nm2, '0', navg, '0']
- [pavg, '0', ratio, '0']
- [navg, '0', ratio, '1']
- [ratio, '0', minus1, '0']
- [minus1, '0', clip, '0']
- [floor, '0', clip, '1']
- [clip, '0', db, '0']
- [db, '0', out0_cn0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
