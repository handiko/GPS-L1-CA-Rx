options:
  parameters:
    category: GPS Lab
    description: Bit sync + differential bit detection + preamble tagging, stock blocks only
    generate_options: hb
    id: gps_nav_bits
    output_language: python
    title: GPS nav bits
  states: {}

blocks:
- name: alpha
  id: parameter
  parameters:
    comment: 'per 20 ms update: 0.05 = ~0.4 s'
    label: Bit-sync smoothing
    type: eng_float
    value: '0.05'
  states: {}
- name: in0_p
  id: pad_source
  parameters:
    comment: prompt correlator, 1 kHz
    label: P
    type: complex
  states: {}
- name: msum
  id: blocks_moving_average_xx
  parameters:
    comment: running 20 ms sum of P (one bit long)
    type: complex
    length: '20'
    scale: '1'
    max_iter: '4000'
  states: {}
- name: m2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: s2v
  id: blocks_stream_to_vector
  parameters:
    comment: 20 alignments side by side
    type: float
    num_items: '20'
  states: {}
- name: hist
  id: single_pole_iir_filter_xx
  parameters:
    comment: energy per alignment, smoothed
    type: float
    alpha: alpha
    vlen: '20'
  states: {}
- name: amax
  id: blocks_argmax_xx
  parameters:
    comment: best alignment = bit phase
    type: float
    num_inputs: '1'
    vlen: '20'
  states: {}
- name: probe
  id: blocks_probe_signal_x
  parameters:
    type: short
  states: {}
- name: null_s
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: bit_phase
  id: variable_function_probe
  parameters:
    comment: reads the argmax twice a second -> Keep 1 in 20 offset
    block_id: probe
    function_name: level
    poll_rate: '2'
    value: '0'
  states: {}
- name: keep
  id: blocks_keep_m_in_n
  parameters:
    comment: one sum per bit, at the bit-sync phase
    type: complex
    m: '1'
    n: '20'
    offset: bit_phase
  states: {}
- name: dly
  id: blocks_delay
  parameters:
    comment: previous bit
    type: complex
    delay: '1'
  states: {}
- name: mconj
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: S(k) * conj(S(k-1))
  states: {}
- name: c2r
  id: blocks_complex_to_real
  parameters:
    comment: <0 means the bit flipped
  states: {}
- name: neg
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '-1.0'
  states: {}
- name: slicer
  id: digital_binary_slicer_fb
  parameters:
    comment: 1 = transition
  states: {}
- name: denc
  id: digital_diff_encoder_bb
  parameters:
    comment: 'running XOR: transitions -> bits (up to one global inversion)'
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: tag1
  id: digital_correlate_access_code_tag_xx
  parameters:
    comment: tag every 10001011
    type: byte
    access_code: '10001011'
    threshold: '0'
    tagname: preamble
  states: {}
- name: tag2
  id: digital_correlate_access_code_tag_xx
  parameters:
    comment: tag every 01110100 (inverted)
    type: byte
    access_code: '01110100'
    threshold: '0'
    tagname: preamble_inv
  states: {}
- name: cmag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: dly2
  id: blocks_delay
  parameters:
    type: float
    delay: '1'
  states: {}
- name: mprod
  id: blocks_multiply_xx
  parameters:
    comment: '|S(k)| |S(k-1)|'
    type: float
  states: {}
- name: eps
  id: blocks_add_const_vxx
  parameters:
    type: float
    const: '1e-9'
  states: {}
- name: cosd
  id: blocks_divide_xx
  parameters:
    comment: 'cos(phase change): +1 same bit, -1 flip'
    type: float
  states: {}
- name: hist1
  id: blocks_add_const_vxx
  parameters:
    comment: +1 so an idle channel gives 0 dB, not -inf
    type: float
    const: '[1.0]*20'
    vlen: '20'
  states: {}
- name: histdb
  id: blocks_nlog10_ff
  parameters:
    comment: energy in dB
    n: '10'
    k: '0'
    vlen: '20'
  states: {}
- name: out0_bits
  id: pad_sink
  parameters:
    comment: 50 bit/s, tagged preambles
    label: bits
    type: byte
  states: {}
- name: out1_soft
  id: pad_sink
  parameters:
    comment: 50 Hz
    label: soft
    type: float
  states: {}
- name: out2_hist
  id: pad_sink
  parameters:
    comment: energy vs alignment in dB, 50 Hz
    label: bitsync
    type: float
    vlen: '20'
  states: {}

connections:
- [in0_p, '0', msum, '0']
- [msum, '0', m2, '0']
- [m2, '0', s2v, '0']
- [s2v, '0', hist, '0']
- [hist, '0', amax, '0']
- [amax, '0', probe, '0']
- [amax, '1', null_s, '0']
- [hist, '0', hist1, '0']
- [hist1, '0', histdb, '0']
- [histdb, '0', out2_hist, '0']
- [msum, '0', keep, '0']
- [keep, '0', mconj, '0']
- [keep, '0', dly, '0']
- [dly, '0', mconj, '1']
- [mconj, '0', c2r, '0']
- [c2r, '0', neg, '0']
- [neg, '0', slicer, '0']
- [slicer, '0', denc, '0']
- [denc, '0', tag1, '0']
- [tag1, '0', tag2, '0']
- [tag2, '0', out0_bits, '0']
- [keep, '0', cmag, '0']
- [cmag, '0', mprod, '0']
- [cmag, '0', dly2, '0']
- [dly2, '0', mprod, '1']
- [mprod, '0', eps, '0']
- [c2r, '0', cosd, '0']
- [eps, '0', cosd, '1']
- [cosd, '0', out1_soft, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
