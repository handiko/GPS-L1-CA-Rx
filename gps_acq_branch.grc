options:
  parameters:
    category: GPS Lab
    description: FFT parallel code-phase search, one Doppler bin per 20 ms, stock blocks only
    generate_options: hb
    id: gps_acq_branch
    output_language: python
    title: GPS acq branch
  states: {}

blocks:
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 2.048e6
  states: {}
- name: f_off
  id: parameter
  parameters:
    comment: 'Branch Doppler offset: 0 for whole-kHz bins, -500 for half-kHz bins'
    label: Pre-mix [Hz]
    type: eng_float
    value: '0'
  states: {}
- name: n_noncoh
  id: parameter
  parameters:
    label: Non-coherent ms
    type: intx
    value: '20'
  states: {}
- name: N
  id: parameter
  parameters:
    comment: 'samp_rate/1000. A parameter, not a variable: GRC sizes hier ports before variables exist'
    label: Samples per ms
    type: intx
    value: '2048'
  states: {}
- name: in0_iq
  id: pad_source
  parameters:
    label: iq
    type: complex
  states: {}
- name: in1_taps
  id: pad_source
  parameters:
    comment: conj(FFT(code)) rotated by m bins (Doppler m kHz), from the scheduler
    label: taps
    type: complex
    vlen: N
  states: {}
- name: lo
  id: analog_sig_source_x
  parameters:
    comment: fixed pre-mix (half-kHz branch)
    type: complex
    samp_rate: samp_rate
    waveform: analog.GR_COS_WAVE
    freq: f_off
    amp: '1'
    offset: '0'
    phase: '0'
  states: {}
- name: mix
  id: blocks_multiply_xx
  parameters:
    comment: x e^(j2pi f_off t)
    type: complex
  states: {}
- name: s2v
  id: blocks_stream_to_vector
  parameters:
    comment: 1 ms blocks (2048 samples)
    type: complex
    num_items: N
  states: {}
- name: fft_f
  id: fft_vxx
  parameters:
    comment: X = FFT(x), rectangular window
    type: complex
    fft_size: N
    forward: 'True'
    window: '[]'
    shift: 'False'
  states: {}
- name: mult
  id: blocks_multiply_xx
  parameters:
    comment: X * C*  (correlation in frequency domain)
    type: complex
    vlen: N
  states: {}
- name: fft_r
  id: fft_vxx
  parameters:
    comment: IFFT -> correlation at all 2048 code phases
    type: complex
    fft_size: N
    forward: 'False'
    window: '[]'
    shift: 'False'
  states: {}
- name: mag2
  id: blocks_complex_to_mag_squared
  parameters:
    comment: '|corr|^2'
    vlen: N
  states: {}
- name: norm1
  id: blocks_multiply_const_vxx
  parameters:
    comment: 'normalise: noise mean = 1 (AGC rms 1)'
    type: float
    const: '[1.0/N**3]*N'
    vlen: N
  states: {}
- name: integ
  id: blocks_integrate_xx
  parameters:
    comment: sum of 20 ms (non-coherent)
    type: float
    decim: n_noncoh
    vlen: N
  states: {}
- name: norm20
  id: blocks_multiply_const_vxx
  parameters:
    comment: mean of 20 ms
    type: float
    const: '[1.0/n_noncoh]*N'
    vlen: N
  states: {}
- name: out0_corr1
  id: pad_sink
  parameters:
    comment: 'probe: one 1 ms correlation'
    label: corr_1ms
    type: float
    vlen: N
  states: {}
- name: out1_corr20
  id: pad_sink
  parameters:
    comment: to the decider (tagged)
    label: corr_20ms
    type: float
    vlen: N
  states: {}

connections:
- [in0_iq, '0', mix, '0']
- [lo, '0', mix, '1']
- [mix, '0', s2v, '0']
- [s2v, '0', fft_f, '0']
- [fft_f, '0', mult, '0']
- [in1_taps, '0', mult, '1']
- [mult, '0', fft_r, '0']
- [fft_r, '0', mag2, '0']
- [mag2, '0', norm1, '0']
- [norm1, '0', out0_corr1, '0']
- [norm1, '0', integ, '0']
- [integ, '0', norm20, '0']
- [norm20, '0', out1_corr20, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
