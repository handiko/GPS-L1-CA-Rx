options:
  parameters:
    description: 'Lab version of gps_l1_despread: stock acquisition branches + 3 EPBs + 3 hier blocks'
    generate_options: qt_gui
    id: gps_l1_lab
    output_language: python
    title: 'GPS L1 C/A lab: acquisition and tracking, every stage probed'
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: int(round(samp_rate*1e-3))
  states: {}
- name: base_path
  id: variable
  parameters:
    comment: Path WITHOUT extension. Use forward slashes on Windows.
    value: '"C:/Users/Handiko/Downloads/GPS-L1-2022-03-27"'
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: GPS L1
    value: 1575.42e6
  states: {}
- name: center_freq_0
  id: variable
  parameters:
    value: float(meta['captures'][0].get('core:frequency', 0))
  states: {}
- name: chips_per_sample
  id: variable
  parameters:
    comment: x-axis scale for code-phase plots
    value: 1.023e6/samp_rate
  states: {}
- name: datatype
  id: variable_qtgui_label
  parameters:
    comment: Shows core:datatype so you know which chain to enable
    label: core:datatype
    type: string
    value: meta['global']['core:datatype']
  states: {}
- name: decim
  id: variable
  parameters:
    comment: display path 2.048 MS/s -> 64 kS/s
    value: '32'
  states: {}
- name: disp_rate
  id: variable
  parameters:
    value: samp_rate/decim
  states: {}
- name: file_samp_rate
  id: variable
  parameters:
    value: float(meta['global']['core:sample_rate'])
  states: {}
- name: lpf_taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, 22e3, 16e3)
  states: {}
- name: m_max
  id: variable
  parameters:
    comment: 'Doppler search +-m_max kHz (TCXO dongle: 6 is enough)'
    value: '10'
  states: {}
- name: meta
  id: variable
  parameters:
    comment: Parsed .sigmf-meta JSON
    value: json.load(open(base_path + '.sigmf-meta'))
  states: {}
- name: n_noncoh
  id: variable
  parameters:
    comment: 'acquisition: 1 ms correlations summed per Doppler bin'
    value: '20'
  states: {}
- name: park_khz
  id: variable_qtgui_range
  parameters:
    comment: Doppler of the parked search, whole kHz (branch 2 adds +0.5 kHz)
    gui_hint: 0,3,1,1
    label: Park Doppler [kHz]
    rangeType: int
    start: '-m_max'
    step: '1'
    stop: m_max
    value: '0'
  states: {}
- name: park_prn
  id: variable_qtgui_range
  parameters:
    comment: 'PARK mode for the acquisition probes: 1..32 holds the search on that PRN, 0 = automatic sweep'
    gui_hint: 0,2,1,1
    label: Park search on PRN (0 = auto)
    rangeType: int
    start: '0'
    step: '1'
    stop: '32'
    value: '0'
  states: {}
- name: ppm
  id: variable_qtgui_range
  parameters:
    comment: 'TCXO dongle: 0'
    gui_hint: 0,1,1,1
    label: Freq corr [ppm]
    start: '-100'
    step: '1'
    stop: '100'
    value: '35'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Active antenna LNA sets the noise figure
    gui_hint: 0,0,1,1
    label: RF gain [dB]
    start: '0'
    step: '0.1'
    stop: '49.6'
    value: '40.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: 2048 samples = one 1 ms C/A period
    value: 2.048e6
  states: {}
- name: threshold
  id: variable
  parameters:
    comment: acquisition peak/mean threshold
    value: '3.5'
  states: {}
- name: acq0
  id: gps_acq_branch
  parameters:
    N: N
    comment: whole-kHz Doppler bins (hier, stock inside)
    f_off: '0'
    n_noncoh: n_noncoh
    samp_rate: samp_rate
  states: {}
- name: acq1
  id: gps_acq_branch
  parameters:
    N: N
    comment: 'half-kHz bins: pre-mixed by -500 Hz'
    f_off: '-500'
    n_noncoh: n_noncoh
    samp_rate: samp_rate
  states: {}
- name: acq_bars
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@1: 2,0,1,2'
    legend: 'False'
    name: '"Decision: peak/mean per PRN (x = PRN - 1), threshold 3.5"'
    size: '32'
    srate: '1'
    stemplot: 'True'
    type: msg_float
    ylabel: peak/mean
    ymax: '25'
    ymin: '0'
  states: {}
- name: acq_corr
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@1: 1,0,1,1'
    legend: 'False'
    name: '"Decision: best Doppler row vs code phase (x = chips), last PRN"'
    size: '2048'
    srate: samp_rate/1.023e6
    type: msg_float
    ylabel: peak/mean
    ymax: '10'
    ymin: '0'
  states: {}
- name: acq_dopp
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@1: 1,1,1,1'
    legend: 'False'
    name: '"Decision: Doppler column at best code phase (x = kHz above -10 kHz)"'
    size: '42'
    srate: '2'
    type: msg_float
    ylabel: peak/mean
    ymax: '10'
    ymin: '0'
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    comment: noise rms -> 1 (time constant ~25 ms)
    gain: '1.0'
    max_gain: '65536'
    rate: '2e-5'
    reference: '1.0'
    type: complex
  states: {}
- name: b2f
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Handiko\gqrx_20261111_085119_1575420000_2400000_fc.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: cn0
  id: qtgui_number_sink
  parameters:
    comment: stock C/N0 meters (hier) per channel
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 'tabs@2: 2,1,1,1'
    label1: '"Ch 0"'
    label2: '"Ch 1"'
    label3: '"Ch 2"'
    label4: '"Ch 3"'
    max: '55'
    min: '20'
    name: '"C/N0 per channel [dB-Hz] (0 = idle)"'
    nconnections: '4'
    type: float
    unit1: '"dB-Hz"'
    unit2: '"dB-Hz"'
    unit3: '"dB-Hz"'
    unit4: '"dB-Hz"'
    update_time: '0.2'
  states: {}
- name: const_p
  id: qtgui_const_sink_x
  parameters:
    comment: Prompt correlator, 1 ms dumps. Two clusters = nav bits; the pair rotates slowly because the FLL locks frequency, not phase
    grid: 'True'
    gui_hint: 'tabs@2: 0,0,1,1'
    label1: '"Ch 0"'
    label2: '"Ch 1"'
    label3: '"Ch 2"'
    label4: '"Ch 3"'
    name: '"Prompt correlator P (each dot = 1 ms)"'
    nconnections: '4'
    size: '500'
    type: complex
    xmax: '400'
    xmin: '-400'
    ymax: '400'
    ymin: '-400'
  states: {}
- name: dcblk
  id: dc_blocker_xx
  parameters:
    comment: removes the RTL DC spike
    length: '1024'
    long_form: 'True'
    type: cc
  states: {}
- name: dec_c0
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: lpf_taps
    type: ccf
  states: {}
- name: dec_c1
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: lpf_taps
    type: ccf
  states: {}
- name: dec_c2
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: lpf_taps
    type: ccf
  states: {}
- name: dec_c3
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: lpf_taps
    type: ccf
  states: {}
- name: dec_raw
  id: fir_filter_xxx
  parameters:
    decim: decim
    taps: lpf_taps
    type: ccf
  states: {}
- name: decider
  id: epy_block
  parameters:
    _source_code: |
      """
      GPS acquisition - decider (Embedded Python Block)

      Inputs : the two stock acquisition branches, each a 2048-float vector per 20 ms
               (|correlation|^2 at all 2048 code phases, 20 ms non-coherent sum).
               in0 = Doppler m kHz, in1 = m kHz + 500 Hz. Each vector carries the
               'acq' = (prn, m) tag from the taps scheduler.
      Builds the 42-row Doppler x 2048 code-phase grid for one PRN, then decides:
               peak/mean > threshold -> parabolic Doppler refinement -> 'assign' message
               to a free tracking channel.
      Messages out: assign (dict), corr / dopp / acq (float PDUs for QT Time Sinks).
      Message in  : status (from trackers: 'lost' frees a channel).
      A candidate must pass two tests: peak/mean > threshold, and the 20 ms sum must have
      averaged at least min_dof independent milliseconds (rejects periodic interference).

      Why an EPB: collecting a 2-D grid across time, picking a peak with a decision rule
      and handing a timing reference to another block has no stock equivalent.
      """
      import time
      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):
          """GPS acq decider: grid -> peak/mean -> assign a tracking channel"""

          def __init__(self, samp_rate=2.048e6, m_max=10, n_noncoh=20, threshold=3.5, n_ch=4,
                       min_dof=5.0):
              self.N = int(round(samp_rate * 1e-3))
              gr.sync_block.__init__(self, name='GPS acq decider',
                                     in_sig=[(np.float32, self.N), (np.float32, self.N)],
                                     out_sig=None)
              self.fs = float(samp_rate)
              self.m_max = int(m_max)
              self.K = int(n_noncoh)
              self.thr = float(threshold)
              self.n_ch = int(n_ch)
              self.min_dof = float(min_dof)
              self.t_warn = 0.0
              self.busy = {}                       # ch -> prn
              self.metric = np.zeros(32, np.float32)
              self.cur = None
              self.rows = {}
              for p in ('assign', 'corr', 'dopp', 'acq'):
                  self.message_port_register_out(pmt.intern(p))
              self.message_port_register_in(pmt.intern('status'))
              self.set_msg_handler(pmt.intern('status'), self._status)

          def _status(self, msg):
              d = pmt.to_python(msg)
              if isinstance(d, dict) and d.get('event') == 'lost':
                  self.busy.pop(int(d['ch']), None)

          def work(self, input_items, output_items):
              a, b = input_items
              base = self.nitems_read(0)
              tags = self.get_tags_in_window(0, 0, len(a), pmt.intern('acq'))
              lab = {t.offset - base: pmt.to_python(t.value) for t in tags}
              for j in range(len(a)):
                  if j not in lab:
                      continue                      # unlabelled (should not happen)
                  prn, m = int(lab[j][0]), int(lab[j][1])
                  if prn == 0:
                      continue                      # warm-up window
                  w = base + j                      # window index: ms [w*K, w*K+K)
                  if self.cur is not None and prn != self.cur:
                      self.rows = {}                # partial sweep (scheduler skipped ahead)
                  self.cur = prn
                  s_mid = (w * self.K + self.K // 2) * self.N    # sample at window middle
                  # each row normalised by its own mean: immune to slow level changes (AGC)
                  self.rows[m * 1000] = (a[j] / max(a[j].mean(), 1e-30), s_mid)
                  self.rows[m * 1000 + 500] = (b[j] / max(b[j].mean(), 1e-30), s_mid)
                  if m == self.m_max:
                      if len(self.rows) == 2 * (2 * self.m_max + 1):
                          self._decide(prn)
                      self.rows, self.cur = {}, None
              return len(a)

          def _decide(self, prn):
              freqs = sorted(self.rows)
              G = np.array([self.rows[f][0] for f in freqs])
              mean = G.mean()
              d, tau = np.unravel_index(np.argmax(G), G.shape)
              metric = G[d, tau] / mean
              self.metric[prn - 1] = metric
              f = float(freqs[d])
              if 0 < d < len(freqs) - 1:            # neighbours: best value within +-2 samples
                  win = [(tau + k) % self.N for k in range(-2, 3)]
                  y0, y1, y2 = G[d - 1, win].max(), G[d, tau], G[d + 1, win].max()
                  den = y0 - 2 * y1 + y2
                  if den < 0:
                      f += 0.5 * (y0 - y2) / den * 500.0
              # second test: did the 20 ms sum really average 20 independent milliseconds?
              # In white noise each cell is a sum of n_noncoh independent |corr|^2 values, so the
              # row (peak excluded) has variance 1/n_noncoh -> effective dof = 1/var ~ 20.
              # Interference that repeats every 1 ms or 125 us (USB / digital noise from the
              # dongle, laptop or bias-tee supply), or a strong CW spur, is IDENTICAL in every
              # millisecond: the sum averages nothing, dof collapses to ~1, and peak/mean reaches
              # ~ln(86000) = 11 for EVERY PRN. Those are rejected here.
              mask = np.ones(self.N, bool)
              mask[[(tau + k) % self.N for k in range(-3, 4)]] = False
              rest = G[d, mask]
              dof = 1.0 / max(np.var(rest / rest.mean()), 1e-9)
              ratio = G[d, tau] / rest.max()
              self._pub('corr', G[d] / mean)
              self._pub('dopp', G[:, tau] / mean)
              self._pub('acq', self.metric)
              if metric < self.thr or prn in self.busy.values():
                  return
              if dof < self.min_dof:
                  now = time.time()
                  if now - self.t_warn > 5.0:
                      self.t_warn = now
                      print('[INTERFERENCE] PRN %02d peak/mean %.1f rejected: the %d ms sum behaves like '
                            '%.1f independent ms (white noise: ~%d). Something repeats every 1 ms: '
                            'look for a picket fence on the raw spectrum.' % (prn, metric, self.K, dof,
                                                                               self.K), flush=True)
                  return
              free = [c for c in range(self.n_ch) if c not in self.busy]
              if not free:
                  return
              ch = free[0]
              s_ref = int(self.rows[freqs[d]][1] + tau)   # a code epoch (chip 0) sample index
              self.busy[ch] = prn
              # s_ref goes out as a float: it passes 2^31 after 17.5 min, and pmt.to_pmt() turns a
              # Python int into a C long, which is 32-bit on Windows. A double is exact to 2^53.
              self.message_port_pub(pmt.intern('assign'), pmt.to_pmt(
                  {'event': 'assign', 'ch': ch, 'prn': prn, 'f': f, 's_ref': float(s_ref)}))
              print('[ACQ] PRN %02d -> ch%d  Doppler %+7.0f Hz  code epoch at sample %d  '
                    'peak/mean %.1f  peak/2nd %.2f  dof %.0f' % (prn, ch, f, s_ref, metric, ratio, dof), flush=True)

          def _pub(self, port, v):
              v = np.asarray(v, np.float32)
              self.message_port_pub(pmt.intern(port),
                                    pmt.cons(pmt.PMT_NIL, pmt.init_f32vector(len(v), v.tolist())))
    comment: 'Decider (EPB): builds the PRN grid, peak/mean, assigns channels'
    m_max: m_max
    min_dof: '5.0'
    n_ch: '4'
    n_noncoh: n_noncoh
    samp_rate: samp_rate
    threshold: threshold
  states: {}
- name: dll
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@2: 1,1,1,1'
    label1: '"Ch 0"'
    label2: '"Ch 1"'
    label3: '"Ch 2"'
    label4: '"Ch 3"'
    name: '"DLL discriminator (chips): replica minus signal, all channels"'
    nconnections: '4'
    size: '1000'
    srate: '1000'
    type: float
    ylabel: '"chips"'
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: epl
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@2: 1,0,1,1'
    label1: '"|E| early"'
    label2: '"|P| prompt"'
    label3: '"|L| late"'
    name: '"Ch 0 |E|, |P|, |L|: on lock |P| on top, |E| = |L| about half of it"'
    nconnections: '3'
    size: '1000'
    srate: '1000'
    type: float
    ylabel: '"|corr|"'
    ymax: '400'
    ymin: '0'
  states: {}
- name: freq
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@2: 2,0,1,1'
    label1: '"Ch 0"'
    label2: '"Ch 1"'
    label3: '"Ch 2"'
    label4: '"Ch 3"'
    name: '"FLL frequency estimate (Hz), all channels, last 5 s"'
    nconnections: '4'
    size: '5000'
    srate: '1000'
    type: float
    ylabel: '"Hz"'
    ymax: '10000'
    ymin: '-10000'
  states: {}
- name: import_json
  id: import
  parameters:
    imports: import json
  states: {}
- name: ishort_to_complex
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: lastnav
  id: qtgui_edit_box_msg
  parameters:
    comment: latest decoder line
    gui_hint: 'tabs@3: 0,0,1,2'
    is_pair: 'False'
    key: '""'
    label: '"Last decoded"'
    type: string
    value: '"waiting for frame sync..."'
  states: {}
- name: me
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: ml
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: mp
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: navdec
  id: epy_block
  parameters:
    _source_code: |
      """
      GPS navigation message decoder (Embedded Python Block)

      Inputs : n_ch byte streams at 50 bit/s, one per tracking channel, from the stock
               gps_nav_bits hier blocks (bit sync -> differential detection -> differential
               encoder -> preamble taggers). Bits are correct up to one overall inversion.
               Stream tags 'preamble' / 'preamble_inv' mark each 10001011 (or 01110100)
               found by the stock Correlate Access Code - Tag blocks.
      Message in  'status' : tracker events {'event','ch','prn'} -> reset that channel.
      Message out 'text'   : the latest decoded line (for a QT GUI Message Edit Box).

      What it does per channel (IS-GPS-200):
        1. Frame sync: a tagged preamble is only a candidate (8 bits occur by chance every
           ~256 bits). It is accepted when TLM and HOW pass the 6-bit parity check, and the
           NEXT subframe, 300 bits later, also passes. Polarity comes from which tag fired.
        2. Every following 300-bit subframe: parity on all 10 words, then decode
           HOW: TOW count (time of week, 6 s units) and subframe ID 1..5
           subframe 1 word 3: 10-bit week number, SV health, URA index, IODC MSBs.
        3. GPS time -> UTC (GPS - 18 s leap seconds; the 10-bit week is unwrapped with
           2 rollovers, valid 2019-04-07 .. 2038-11-20).

      Why an EPB: parity checking with the D29*/D30* chaining, frame validation across
      subframes and field decoding have no stock GNU Radio equivalent.
      """
      import datetime
      import numpy as np
      from gnuradio import gr
      import pmt

      PREAMBLE = [1, 0, 0, 0, 1, 0, 1, 1]
      LEAP_S = 18
      GPS_EPOCH = datetime.datetime(1980, 1, 6)
      # parity equations: which data bits (1-based) feed each parity bit, and whether D29* or D30*
      PAR = [(29, [1, 2, 3, 5, 6, 10, 11, 12, 13, 14, 17, 18, 20, 23]),
             (30, [2, 3, 4, 6, 7, 11, 12, 13, 14, 15, 18, 19, 21, 24]),
             (29, [1, 3, 4, 5, 7, 8, 12, 13, 14, 15, 16, 19, 20, 22]),
             (30, [2, 4, 5, 6, 8, 9, 13, 14, 15, 16, 17, 20, 21, 23]),
             (30, [1, 3, 5, 6, 7, 9, 10, 14, 15, 16, 17, 18, 21, 22, 24]),
             (29, [3, 5, 6, 8, 9, 10, 11, 13, 15, 19, 22, 23, 24])]


      def word_ok(w30, d29s, d30s):
          """w30: 30 transmitted bits. Returns (ok, 24 source data bits)."""
          data = [b ^ d30s for b in w30[:24]]
          star = {29: d29s, 30: d30s}
          for k, (s, idx) in enumerate(PAR):
              p = star[s]
              for i in idx:
                  p ^= data[i - 1]
              if p != w30[24 + k]:
                  return False, data
          return True, data


      def subframe_check(bits, d29s, d30s, n_words=10):
          """bits: 300 transmitted bits (polarity already corrected). Returns list of
          24-bit data words, or None if any parity check fails."""
          words = []
          for w in range(n_words):
              w30 = bits[30 * w:30 * w + 30]
              ok, data = word_ok(w30, d29s, d30s)
              if not ok:
                  return None
              words.append(data)
              d29s, d30s = w30[28], w30[29]
          return words


      def words_check(bits, d29s, d30s):
          """all 10 words; returns (data words, list of per-word parity results)"""
          words, ok = [], []
          for w in range(10):
              w30 = bits[30 * w:30 * w + 30]
              good, data = word_ok(w30, d29s, d30s)
              words.append(data)
              ok.append(good)
              d29s, d30s = w30[28], w30[29]
          return words, ok


      def uint(bits):
          v = 0
          for b in bits:
              v = (v << 1) | int(b)
          return v


      def gps_to_utc(week_full, tow_s):
          return GPS_EPOCH + datetime.timedelta(weeks=week_full, seconds=tow_s - LEAP_S)


      class blk(gr.sync_block):
          """GPS nav decoder: frame sync, parity, TOW / subframe / week number -> UTC"""

          def __init__(self, n_ch=4):
              self.n = int(n_ch)
              gr.sync_block.__init__(self, name='GPS nav decoder',
                                     in_sig=[np.uint8] * self.n, out_sig=None)
              self.message_port_register_in(pmt.intern('status'))
              self.set_msg_handler(pmt.intern('status'), self._status)
              self.message_port_register_out(pmt.intern('text'))
              self.st = [self._fresh(None) for _ in range(self.n)]

          @staticmethod
          def _fresh(prn):
              return dict(prn=prn, buf=[], base=0, cands=[], lock=None, pol=0, week=None,
                          n_ok=0, n_bad=0)

          def _status(self, msg):
              d = pmt.to_python(msg)
              if isinstance(d, dict) and 0 <= int(d.get('ch', -1)) < self.n:
                  ch = int(d['ch'])
                  self.st[ch] = self._fresh(int(d['prn']) if d.get('event') == 'assigned' else None)

          def _say(self, line):
              print(line, flush=True)
              self.message_port_pub(pmt.intern('text'), pmt.intern(line))

          def work(self, input_items, output_items):
              n = len(input_items[0])
              for c in range(self.n):
                  st = self.st[c]
                  r0 = self.nitems_read(c)
                  if not st['buf']:
                      st['base'] = r0
                  st['buf'].extend(int(b) & 1 for b in input_items[c])
                  for key, pol in (('preamble', 0), ('preamble_inv', 1)):
                      for t in self.get_tags_in_window(c, 0, n, pmt.intern(key)):
                          # tag sits on the bit after the 8-bit code -> subframe starts 8 earlier
                          st['cands'].append((t.offset - 8, pol))
                  if st['prn'] is not None:
                      self._process(c, st)
                  else:
                      st['cands'] = []
                  keep = 900                                # bits kept (3 subframes)
                  if len(st['buf']) > keep + 1200:
                      drop = len(st['buf']) - keep
                      st['buf'] = st['buf'][drop:]
                      st['base'] += drop
              return n

          def _get(self, st, start, length):
              i = start - st['base']
              if i < 0 or i + length > len(st['buf']):
                  return None
              return st['buf'][i:i + length]

          def _process(self, c, st):
              if st['lock'] is None:                       # frame sync from candidates
                  still = []
                  for (s, pol) in st['cands']:
                      seg = self._get(st, s - 2, 602)       # D29*, D30* + two subframes
                      if seg is None:
                          if s - 2 >= st['base']:
                              still.append((s, pol))         # wait for more bits
                          continue
                      seg = [b ^ pol for b in seg]
                      a = words_check(seg[2:302], seg[0], seg[1])[1]
                      b = words_check(seg[302:602], seg[300], seg[301])[1]
                      pre2 = seg[302:310] in (PREAMBLE, [x ^ 1 for x in PREAMBLE])
                      if a[0] and a[1] and b[0] and b[1] and pre2:
                          st['lock'], st['pol'] = s, pol
                          self._say('[NAV ch%d] PRN %02d frame sync: preamble at bit %d, polarity %s, '
                                    'TLM+HOW parity OK on two consecutive subframes' % (
                                        c, st['prn'], s, 'inverted' if pol else 'normal'))
                          break
                  else:
                      st['cands'] = still
                  if st['lock'] is None:
                      return
                  st['cands'] = []
              while True:                                   # decode every complete subframe
                  s = st['lock']
                  seg = self._get(st, s - 2, 302)
                  if seg is None:
                      return
                  st['lock'] = s + 300
                  # polarity per subframe from its own preamble: differential detection makes
                  # every misread transition invert all later bits. GPS parity survives that by
                  # design (each word is checked against the previous word's last two RECEIVED
                  # bits), so only the word containing the flip is lost.
                  if seg[2:10] == PREAMBLE:
                      pol = 0
                  elif [b ^ 1 for b in seg[2:10]] == PREAMBLE:
                      pol = 1
                  else:
                      pol = None
                  words, ok = words_check(seg[2:302], seg[0], seg[1]) if pol is not None else (None, [False] * 10)
                  if not (ok[0] and ok[1]):                 # TLM + HOW are the minimum
                      st['n_bad'] += 1
                      self._say('[NAV ch%d] PRN %02d subframe at bit %d: TLM/HOW parity FAIL (%d in a row)'
                                % (c, st['prn'], s, st['n_bad']))
                      if st['n_bad'] >= 3:                  # lost frame sync: search again
                          self._say('[NAV ch%d] PRN %02d frame sync lost, searching' % (c, st['prn']))
                          st['lock'], st['n_bad'] = None, 0
                          return
                      continue
                  st['n_bad'] = 0
                  st['n_ok'] += 1
                  self._decode(c, st, words, ok)

          def _decode(self, c, st, w, ok):
              how = w[1]
              tow_next = uint(how[0:17]) * 6               # TOW at start of NEXT subframe
              sfid = uint(how[19:22])
              tow = tow_next - 6                           # TOW at start of THIS subframe
              extra = ''
              bad = [i + 1 for i in range(10) if not ok[i]]
              if bad:
                  extra = '  (parity fail in word %s)' % ','.join(map(str, bad))
              if sfid == 1 and ok[2]:
                  wn10 = uint(w[2][0:10])
                  st['week'] = wn10 + 2048                 # two rollovers (since April 2019)
                  ura, health, iodc_msb = uint(w[2][12:16]), uint(w[2][16:22]), uint(w[2][22:24])
                  iodc = (iodc_msb << 8) | uint(w[7][0:8]) if ok[7] else -1
                  extra += '  week %d (10-bit %d), URA %d, health %s, IODC %d' % (
                      st['week'], wn10, ura, 'OK' if health == 0 else '0x%02X' % health, iodc)
              d, rem = divmod(tow, 86400)
              hh, rem = divmod(rem, 3600)
              mm, ss = divmod(rem, 60)
              dow = ['Sun', 'Mon', 'Tue', 'Wed', 'Thu', 'Fri', 'Sat'][d % 7]
              line = '[NAV ch%d] PRN %02d subframe %d  TOW %6d s = %s %02d:%02d:%02d GPS%s' % (
                  c, st['prn'], sfid, tow, dow, hh, mm, ss, extra)
              if st['week'] is not None:
                  line += '  -> UTC %s' % gps_to_utc(st['week'], tow).strftime('%Y-%m-%d %H:%M:%S')
              self._say(line)
    comment: 'Nav decoder (EPB): frame sync, parity, TOW, subframe ID, week -> UTC'
    n_ch: '4'
  states: {}
- name: nb0
  id: gps_nav_bits
  parameters:
    alpha: '0.05'
    comment: bit sync + bits, ch 0 (hier, stock inside)
  states: {}
- name: nb1
  id: gps_nav_bits
  parameters:
    alpha: '0.05'
    comment: bit sync + bits, ch 1 (hier, stock inside)
  states: {}
- name: nb2
  id: gps_nav_bits
  parameters:
    alpha: '0.05'
    comment: bit sync + bits, ch 2 (hier, stock inside)
  states: {}
- name: nb3
  id: gps_nav_bits
  parameters:
    alpha: '0.05'
    comment: bit sync + bits, ch 3 (hier, stock inside)
  states: {}
- name: null_acq1
  id: blocks_null_sink
  parameters:
    type: float
    vlen: N
  states: {}
- name: null_el
  id: blocks_null_sink
  parameters:
    comment: E and L of ch 1-3 are not displayed
    num_inputs: '6'
    type: complex
  states: {}
- name: p_iq
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@2: 0,1,1,1'
    label1: '"I (in-phase)"'
    label2: '"Q (quadrature)"'
    name: '"Ch 0 prompt P, I and Q over 1 s: 50 bit/s navigation data (20 ms per bit)"'
    size: '1000'
    srate: '1000'
    type: complex
    ylabel: '"P"'
    ymax: '400'
    ymin: '-400'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(file_samp_rate)
    interp: int(samp_rate)
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: int(2.4e6)
    interp: int(samp_rate)
    type: ccc
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    corr0: ppm
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: scale_ci16
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normalize to +/-1.0
    const: 1.0/32768
    type: complex
  states: {state: disabled}
- name: sched
  id: epy_block
  parameters:
    _source_code: |
      """
      GPS acquisition - taps scheduler (Embedded Python Block)

      Clocked by the raw 2.048 MS/s stream: one output vector per 1 ms (2048 samples).
      Output = the replica spectrum conj(FFT(C/A code)) of the PRN under test, circularly
      rotated by m bins. With 1 kHz bin spacing (2048-pt FFT at 2.048 MS/s), rotating the
      code spectrum by m bins is the same as testing a Doppler of m kHz:
          |IFFT( FFT(x * e^-j2pi m n/N) * C* )| = |IFFT( FFT(x) * roll(C*, m) )|
      so the stock Multiply in the acquisition branches does the Doppler search too.
      The half-kHz bins come from a second branch pre-mixed by -500 Hz.

      The first warmup_ms (default 500 ms) are tagged PRN 0 and ignored, while the AGC
      settles. After that, the hypothesis (PRN, m) changes only on 20 ms boundaries (aligned with the stock
      Integrate decim=20), and each change is stamped with a stream tag 'acq' = (prn, m).
      The tag rides through Multiply, IFFT, Mag^2 and Integrate to the decider, so every
      integrated result is labelled exactly: no guessing about buffer latency.

      PARK mode (park_prn = 1..32): the scheduler holds PRN park_prn at Doppler park_khz kHz
      (and park_khz + 0.5 kHz in the second branch) so the 1 ms and 20 ms probes can be
      watched. park_prn = 0 resumes the automatic sweep. No decisions are made while parked.

      Why an EPB: no stock block produces a vector sequence that changes on a schedule
      and skips PRNs that are already being tracked (message input 'status').
      """
      import numpy as np
      from gnuradio import gr
      import pmt

      G2_TAPS = {1: (2, 6), 2: (3, 7), 3: (4, 8), 4: (5, 9), 5: (1, 9), 6: (2, 10),
                 7: (1, 8), 8: (2, 9), 9: (3, 10), 10: (2, 3), 11: (3, 4), 12: (5, 6),
                 13: (6, 7), 14: (7, 8), 15: (8, 9), 16: (9, 10), 17: (1, 4), 18: (2, 5),
                 19: (3, 6), 20: (4, 7), 21: (5, 8), 22: (6, 9), 23: (1, 3), 24: (4, 6),
                 25: (5, 7), 26: (6, 8), 27: (7, 9), 28: (8, 10), 29: (1, 6), 30: (2, 7),
                 31: (3, 8), 32: (4, 9)}


      def ca_code(prn):
          g1, g2 = [1] * 10, [1] * 10
          a, b = G2_TAPS[prn]
          out = np.empty(1023, np.float32)
          for i in range(1023):
              out[i] = 1 - 2 * (g1[9] ^ g2[a - 1] ^ g2[b - 1])
              g1 = [g1[2] ^ g1[9]] + g1[:9]
              g2 = [g2[1] ^ g2[2] ^ g2[5] ^ g2[7] ^ g2[8] ^ g2[9]] + g2[:9]
          return out


      class blk(gr.decim_block):
          """GPS acq taps scheduler: conj(FFT(code)) rotated by Doppler, tagged (prn, m)"""

          def __init__(self, samp_rate=2.048e6, m_max=10, n_noncoh=20, warmup_ms=500,
                       park_prn=0, park_khz=0):
              self.N = int(round(samp_rate * 1e-3))
              gr.decim_block.__init__(self, name='GPS acq taps scheduler',
                                      in_sig=[np.complex64],
                                      out_sig=[(np.complex64, self.N)], decim=self.N)
              self.m_max = int(m_max)
              self.K = int(n_noncoh)
              n = np.arange(self.N)
              idx = np.floor(n * 1.023e6 / samp_rate).astype(int) % 1023
              self.cconj = {p: np.conj(np.fft.fft(ca_code(p)[idx])).astype(np.complex64)
                            for p in range(1, 33)}
              self.ms_list = list(range(-self.m_max, self.m_max + 1))
              self.prn, self.mi = 1, -1
              self.taps = None
              self.tracked = set()
              self.park_prn = int(park_prn)          # GRC callback sets these live
              self.park_khz = int(park_khz)
              self.warm = int(warmup_ms) // self.K * self.K   # whole windows of warm-up
              self.zero = np.zeros(self.N, np.complex64)
              self.set_output_multiple(self.K)          # one call = one 20 ms window
              self.message_port_register_in(pmt.intern('status'))
              self.set_msg_handler(pmt.intern('status'), self._status)

          def _status(self, msg):
              d = pmt.to_python(msg)
              if not isinstance(d, dict):
                  return
              if d.get('event') in ('assign', 'assigned'):
                  self.tracked.add(int(d['prn']))
              elif d.get('event') == 'lost':
                  self.tracked.discard(int(d['prn']))

          def _next(self):
              self.mi += 1
              if self.mi >= len(self.ms_list):
                  self.mi = 0
                  for _ in range(32):                      # next PRN not being tracked
                      self.prn = self.prn % 32 + 1
                      if self.prn not in self.tracked or len(self.tracked) >= 32:
                          break
              m = self.ms_list[self.mi]
              self.taps = np.roll(self.cconj[self.prn], m)
              return m

          def work(self, input_items, output_items):
              out = output_items[0]
              base = self.nitems_written(0)
              for j in range(len(out)):
                  ms = base + j
                  if ms < self.warm:                  # AGC / DC blocker settling: PRN 0 = ignore
                      if ms == 0:
                          self.add_item_tag(0, 0, pmt.intern('acq'),
                                            pmt.make_tuple(pmt.from_long(0), pmt.from_long(0)))
                      out[j] = self.zero
                      continue
                  if ms % self.K == 0 and 1 <= int(self.park_prn) <= 32:
                      # PARK mode: hold one hypothesis so the probes can be watched
                      prn = int(self.park_prn)
                      m = int(max(-self.m_max, min(self.m_max, int(self.park_khz))))
                      self.taps = np.roll(self.cconj[prn], m)
                      self.add_item_tag(0, ms, pmt.intern('acq'),
                                        pmt.make_tuple(pmt.from_long(prn), pmt.from_long(m)))
                  elif ms % self.K == 0 or self.taps is None:
                      m = self._next()
                      self.add_item_tag(0, ms, pmt.intern('acq'),
                                        pmt.make_tuple(pmt.from_long(self.prn), pmt.from_long(m)))
                  out[j] = self.taps
              return len(out)
    comment: 'Taps scheduler (EPB): which PRN / Doppler is tested in each 20 ms window, tagged'
    m_max: m_max
    n_noncoh: n_noncoh
    park_khz: park_khz
    park_prn: park_prn
    samp_rate: samp_rate
    warmup_ms: '500'
  states: {}
- name: spec
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: disp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '512'
    grid: 'True'
    gui_hint: 'tabs@0: 0,0,1,2'
    label1: '"Raw input"'
    label2: '"Ch 0"'
    label3: '"Ch 1"'
    label4: '"Ch 2"'
    label5: '"Ch 3"'
    name: '"Despread spectrum (offset from 1575.42 MHz, 250 Hz bins)"'
    nconnections: '5'
    type: complex
    width2: '2'
    width3: '2'
    width4: '2'
    width5: '2'
    ymax: '-15'
    ymin: '-55'
  states: {}
- name: src_ci16
  id: blocks_file_source
  parameters:
    comment: ci16_le
    file: base_path + '.sigmf-data'
    repeat: 'True'
    type: short
  states: {state: disabled}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,1,4
    label0: Spectrum (despread)
    label1: Acquisition (search)
    label2: Tracking (loop internals)
    label3: Navigation data
    num_tabs: '4'
  states: {}
- name: trk0
  id: gps_track_channel
  parameters:
    ch: '0'
    comment: 'tracking channel 0 (hier: EPB + stock)'
    dll_gain: '0.3'
    fll_gain: '0.05'
    fll_narrow: '0.05'
    pll_bw: '25'
    pll_on: '1'
    samp_rate: samp_rate
  states: {}
- name: trk1
  id: gps_track_channel
  parameters:
    ch: '1'
    comment: 'tracking channel 1 (hier: EPB + stock)'
    dll_gain: '0.3'
    fll_gain: '0.05'
    fll_narrow: '0.05'
    pll_bw: '25'
    pll_on: '1'
    samp_rate: samp_rate
  states: {}
- name: trk2
  id: gps_track_channel
  parameters:
    ch: '2'
    comment: 'tracking channel 2 (hier: EPB + stock)'
    dll_gain: '0.3'
    fll_gain: '0.05'
    fll_narrow: '0.05'
    pll_bw: '25'
    pll_on: '1'
    samp_rate: samp_rate
  states: {}
- name: trk3
  id: gps_track_channel
  parameters:
    ch: '3'
    comment: 'tracking channel 3 (hier: EPB + stock)'
    dll_gain: '0.3'
    fll_gain: '0.05'
    fll_narrow: '0.05'
    pll_bw: '25'
    pll_on: '1'
    samp_rate: samp_rate
  states: {}
- name: ts_bits
  id: qtgui_time_sink_x
  parameters:
    comment: tags mark each candidate preamble
    grid: 'True'
    gui_hint: 'tabs@3: 3,0,2,2'
    legend: 'False'
    name: '"Ch 0 decoded bits, last 12 s (tags = preamble candidates)"'
    size: '600'
    srate: '50'
    type: float
    update_time: '0.20'
    ylabel: '"bit"'
    ymax: '1.5'
    ymin: '-0.5'
  states: {}
- name: ts_soft
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 'tabs@3: 1,1,2,1'
    label1: '"Ch 0"'
    label2: '"Ch 1"'
    label3: '"Ch 2"'
    label4: '"Ch 3"'
    name: '"cos(phase change between bits): +1 same bit, -1 bit flip (6 s = 1 subframe)"'
    nconnections: '4'
    size: '300'
    srate: '50'
    type: float
    update_time: '0.20'
    ylabel: '"cos"'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: vs_1ms
  id: qtgui_vector_sink_f
  parameters:
    comment: 'Too noisy to trust: a satellite is only a few times the mean here'
    grid: 'True'
    gui_hint: 'tabs@1: 0,0,1,1'
    label1: '"1 ms"'
    name: '"Probe: ONE 1 ms correlation (whole-kHz branch)"'
    update_time: '0.05'
    vlen: N
    x_axis_label: '"code phase"'
    x_start: '0'
    x_step: chips_per_sample
    x_units: '"chips"'
    y_axis_label: '"peak/mean"'
    ymax: '40'
    ymin: '0'
  states: {}
- name: vs_20ms
  id: qtgui_vector_sink_f
  parameters:
    comment: Noise flattens towards 1; a satellite spike stands up
    grid: 'True'
    gui_hint: 'tabs@1: 0,1,1,1'
    label1: '"m kHz"'
    label2: '"m kHz + 500 Hz"'
    name: '"Probe: 20 ms sums, both branches (current PRN / Doppler under test)"'
    nconnections: '2'
    update_time: '0.05'
    vlen: N
    x_axis_label: '"code phase"'
    x_start: '0'
    x_step: chips_per_sample
    x_units: '"chips"'
    y_axis_label: '"peak/mean"'
    ymax: '40'
    ymin: '0'
  states: {}
- name: vs_bitsync
  id: qtgui_vector_sink_f
  parameters:
    comment: peak = where the bit edges are
    grid: 'True'
    gui_hint: 'tabs@3: 1,0,2,1'
    label1: '"Ch 0"'
    label2: '"Ch 1"'
    label3: '"Ch 2"'
    label4: '"Ch 3"'
    name: '"Bit sync: energy of a 20 ms sum vs its start offset (peak = bit edge), per channel"'
    nconnections: '4'
    update_time: '0.20'
    vlen: '20'
    x_axis_label: '"start offset"'
    x_start: '0'
    x_step: '1'
    x_units: '"ms"'
    y_axis_label: '"energy"'
    y_units: '"dB"'
    ymax: '80'
    ymin: '55'
  states: {}
- name: wf_c0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: disp_rate
    fc: '0'
    fftsize: '512'
    gui_hint: 'tabs@0: 1,1,1,1'
    int_max: '-28'
    int_min: '-50'
    legend: 'False'
    name: '"Waterfall: channel 0 (line appears at lock)"'
    type: complex
    update_time: '0.05'
  states: {}
- name: wf_raw
  id: qtgui_waterfall_sink_x
  parameters:
    bw: disp_rate
    fc: '0'
    fftsize: '512'
    gui_hint: 'tabs@0: 1,0,1,1'
    int_max: '-28'
    int_min: '-50'
    legend: 'False'
    name: '"Waterfall: raw input (nothing to see)"'
    type: complex
    update_time: '0.05'
  states: {}

connections:
- [acq0, '0', vs_1ms, '0']
- [acq0, '1', decider, '0']
- [acq0, '1', vs_20ms, '0']
- [acq1, '0', null_acq1, '0']
- [acq1, '1', decider, '1']
- [acq1, '1', vs_20ms, '1']
- [agc, '0', acq0, '0']
- [agc, '0', acq1, '0']
- [agc, '0', dec_raw, '0']
- [agc, '0', sched, '0']
- [agc, '0', trk0, '0']
- [agc, '0', trk1, '0']
- [agc, '0', trk2, '0']
- [agc, '0', trk3, '0']
- [b2f, '0', ts_bits, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_throttle2_0, '0', dcblk, '0']
- [dcblk, '0', agc, '0']
- [dec_c0, '0', spec, '1']
- [dec_c0, '0', wf_c0, '0']
- [dec_c1, '0', spec, '2']
- [dec_c2, '0', spec, '3']
- [dec_c3, '0', spec, '4']
- [dec_raw, '0', spec, '0']
- [dec_raw, '0', wf_raw, '0']
- [decider, acq, acq_bars, in]
- [decider, assign, sched, status]
- [decider, assign, trk0, assign]
- [decider, assign, trk1, assign]
- [decider, assign, trk2, assign]
- [decider, assign, trk3, assign]
- [decider, corr, acq_corr, in]
- [decider, dopp, acq_dopp, in]
- [ishort_to_complex, '0', scale_ci16, '0']
- [me, '0', epl, '0']
- [ml, '0', epl, '2']
- [mp, '0', epl, '1']
- [navdec, text, lastnav, val]
- [nb0, '0', b2f, '0']
- [nb0, '0', navdec, '0']
- [nb0, '1', ts_soft, '0']
- [nb0, '2', vs_bitsync, '0']
- [nb1, '0', navdec, '1']
- [nb1, '1', ts_soft, '1']
- [nb1, '2', vs_bitsync, '1']
- [nb2, '0', navdec, '2']
- [nb2, '1', ts_soft, '2']
- [nb2, '2', vs_bitsync, '2']
- [nb3, '0', navdec, '3']
- [nb3, '1', ts_soft, '3']
- [nb3, '2', vs_bitsync, '3']
- [rational_resampler_xxx_0, '0', blocks_throttle2_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_throttle2_0, '0']
- [rtlsdr_source_0, '0', dcblk, '0']
- [scale_ci16, '0', rational_resampler_xxx_0, '0']
- [sched, '0', acq0, '1']
- [sched, '0', acq1, '1']
- [src_ci16, '0', ishort_to_complex, '0']
- [trk0, '0', dec_c0, '0']
- [trk0, '1', const_p, '0']
- [trk0, '1', mp, '0']
- [trk0, '1', nb0, '0']
- [trk0, '1', p_iq, '0']
- [trk0, '2', me, '0']
- [trk0, '3', ml, '0']
- [trk0, '4', dll, '0']
- [trk0, '5', freq, '0']
- [trk0, '6', cn0, '0']
- [trk0, status, decider, status]
- [trk0, status, navdec, status]
- [trk0, status, sched, status]
- [trk1, '0', dec_c1, '0']
- [trk1, '1', const_p, '1']
- [trk1, '1', nb1, '0']
- [trk1, '2', null_el, '0']
- [trk1, '3', null_el, '1']
- [trk1, '4', dll, '1']
- [trk1, '5', freq, '1']
- [trk1, '6', cn0, '1']
- [trk1, status, decider, status]
- [trk1, status, navdec, status]
- [trk1, status, sched, status]
- [trk2, '0', dec_c2, '0']
- [trk2, '1', const_p, '2']
- [trk2, '1', nb2, '0']
- [trk2, '2', null_el, '2']
- [trk2, '3', null_el, '3']
- [trk2, '4', dll, '2']
- [trk2, '5', freq, '2']
- [trk2, '6', cn0, '2']
- [trk2, status, decider, status]
- [trk2, status, navdec, status]
- [trk2, status, sched, status]
- [trk3, '0', dec_c3, '0']
- [trk3, '1', const_p, '3']
- [trk3, '1', nb3, '0']
- [trk3, '2', null_el, '4']
- [trk3, '3', null_el, '5']
- [trk3, '4', dll, '3']
- [trk3, '5', freq, '3']
- [trk3, '6', cn0, '3']
- [trk3, status, decider, status]
- [trk3, status, navdec, status]
- [trk3, status, sched, status]

metadata:
  file_format: 1
  grc_version: 3.10.10.0
